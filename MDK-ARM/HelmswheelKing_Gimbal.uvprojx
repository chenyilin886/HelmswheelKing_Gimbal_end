# Keil uVision project HelmswheelKing_Gimbal.uvprojx, settings and files
target HelmswheelKing_Gimbal (6210000::V6.21::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: HelmswheelKing_Gimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP/Gimbal;../Alg/Filter;../Alg/PID;../Alg/Feedforward;../HAL/CAN;../HAL/UART;../BSP/Common/FiniteStateMachine;../BSP/Common/StateWatch;../BSP/Motor/DM;../BSP/RemoteControl;../BSP/Motor;../User
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group BSP
    ../BSP/Common/FiniteStateMachine/: FiniteStateMachine_chassis.cpp FiniteStateMachine_gimbal.cpp FiniteStateMachine_launch.cpp
    ../BSP/Common/StateWatch/: buzzer_manager.cpp state_watch.cpp
    ../BSP/RemoteControl/: DT7.cpp
  group ALG
    ../Alg/PID/: pid.cpp
    ../Alg/Feedforward/: Feedforward.cpp Feedforward.hpp
    ../Alg/Filter/: Filter.cpp
  group HAL
    ../HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ../HAL/UART/impl/: uart_bus_impl.cpp uart_device_impl.cpp
    ../HAL/UART/interface/: uart_bus.cpp
  group User
    ../User/: gimbal_c_api.h gimbal_control.cpp gimbal_control.hpp gimbal_to_chassis.cpp gimbal_to_chassis.hpp
software components: CMSIS:CORE 5.6.0
