# Keil uVision project SG_GIMBAL_C_2025_2_7.uvprojx, settings and files
target SG_GIMBAL_C_2025_2_7 (6140001::V6.14.1::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SG_GIMBAL_C_2025_2_7 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HAL
    ../User/HAL/CAN/: can_hal.hpp
    ../User/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../User/HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ../User/HAL/UART/impl/: uart_bus_impl.cpp uart_device_impl.cpp
    ../User/HAL/UART/interface/: uart_bus.cpp uart_device.hpp
    ../User/HAL/UART/: uart_hal.hpp
  group BSP
    ../User/BSP/IMU/: HI12H3_IMU.cpp
    ../User/BSP/: Init.cpp
    ../User/BSP/Remote/Mini/: Mini.cpp
    ../User/BSP/Remote/Dbus/: Dbus.cpp
    ../User/BSP/Motor/DM/: DmMotor.hpp
    ../User/BSP/Motor/Dji/: DjiMotor.hpp
    ../User/BSP/Common/StateWatch/: state_watch.cpp buzzer_manager.cpp
  group APP
    ../User/APP/: Buzzer.cpp LED.cpp Tools.cpp Variable.cpp
    ../User/APP/KeyBorad/: KeyBroad.cpp
    ../User/APP/Heat_Detector/: Heat_Control.cpp
  group Task
    ../User/Task/: CommunicationTask.cpp CallBack.cpp GimbalTask.cpp EvenTask.cpp ShootTask.cpp
    ../User/Task/RemoteSwitch/: RemoteSwitchTask.cpp
  group Algorithm
    ../User/Algorithm/: PID.cpp
    ../User/Algorithm/LADRC/: Adrc.cpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group CRC
    ../User/BSP/CRC/: crc.cpp
  group DWT
    ../User/BSP/DWT/: DWT.cpp
software components: CMSIS:CORE 6.1.0
